# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Code/: I2C.c I2C.h main.c OLED.c OLED.h OLEDFont.h PictureBMP.h ds1302.c page.c key.c
